# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: HallCore110 CORERIVER
  cpu: IRAM(0x00-0x7F) IROM(0x000-0x37F) CLOCK(6000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: bubble.s
